# Keil uVision project Lab2.uvproj, settings and files
target Lab2 (ARM-ADS)
  device: TM4C1233H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: nvmdk PART _LM4F120H5QR
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: Lab2.c ADC.c ST7735.c UART2.c SysTick.c startup.s OS.c cr4_fft_64_stm32.s PID_stm32.s
